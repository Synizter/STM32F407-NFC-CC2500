<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32F411_NFC_CC2500.ewp</path>
  </project>
  <batchBuild/>
</workspace>


