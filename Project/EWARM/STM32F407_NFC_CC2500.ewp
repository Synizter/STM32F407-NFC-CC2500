# IAR project STM32F407_NFC_CC2500.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE; USE_HSE_BYPASS; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Include; ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Include; ..\..\Utility\cc2500\bsp\boards\STM32F407; ..\..\Utility\cc2500\mrfi; ..\..\Utility\cc2500\bsp; ..\..\Utility\cc2500\nwk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Module/CC2500/BSP
    ../../Utility/cc2500/bsp/boards/STM32F407/: bsp_f407.c bsp_mcu_defs.h mrfi_config.h mrfi_lowlevel.c mrfi_lowlevel.h
    ../../Utility/cc2500/nwk/: network.c
  group Module/CC2500/MRFI
    ../../Utility/cc2500/mrfi/: mrfi.h mrfi_defs.h mrfi_f1f2.c mrfi_f1f2.h mrfi_radio.c mrfi_spi.c mrfi_spi.h
  group Std_PeriphDriver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group User
    ../Source/: main.c stm32f4xx_it.c
